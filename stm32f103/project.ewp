# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: RT_USING_DLIBC; STM32F103xE; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: libraries\HAL_Drivers\config; rt-thread\include; libraries\HAL_Drivers; rt-thread\libcpu\arm\common; rt-thread\libcpu\arm\cortex-m3; rt-thread\components\finsh; .; applications; rt-thread\components\libc\posix\io\poll; libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include; rt-thread\components\drivers\include; board; libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc; rt-thread\components\libc\posix\ipc; libraries\STM32F1xx_HAL\CMSIS\Include; board\CubeMX_Config\Inc; rt-thread\components\libc\compilers\common\extension; rt-thread\components\libc\posix\io\stdio; rt-thread\components\libc\compilers\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/common/: time.c stdlib.c
    rt-thread/components/libc/compilers/dlib/: environ.c syscall_mem.c syscall_write.c syscall_close.c syscall_remove.c syscall_open.c syscall_lseek.c syscalls.c syscall_read.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c backtrace.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/ipc/: dataqueue.c ringblk_buf.c completion.c pipe.c workqueue.c ringbuffer.c waitqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_soft_i2c.c drv_common.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c
  group Kernel
    rt-thread/src/: thread.c clock.c components.c scheduler.c device.c mem.c mempool.c idle.c irq.c ipc.c kservice.c timer.c object.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_i2c.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
